# Keil uVision project CM5_ASIX.uvproj, settings and files
target CM5 (MCS-51)
  device: DP80390XP Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2 MOD517AU
  output: ax11000 +hex
  AfterMake: .\BUILD\hex2bin -s 0000 .\BUILD\ax11000.hex
  AfterMake: .\BUILD\makeruntime.exe .\BUILD\ax11000.bin .\binfile\cm5_asix.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: KEIL_AX11000
  c include: ..\SRC\FreeRTOSSource\include\;..\SRC\FreeRTOSSource\portable\Keil\AX11000;..\SRC\CPU\;..\SRC\MS_TIMER\;..\SRC\SW_DMA\;..\SRC\UART\;..\SRC\ETHERNET\;..\SRC\APPLICATION\;..\SRC\ETHERNET\;..\SRC\tcpip\;..\SRC\ADAPTER;..\SRC\main;..\SRC\SD_Card\;..\SRC\GSM\;..\SRC\Web\;..\SRC\SPI\;..\SRC\I2C\;..\SRC\PCA\;..\SRC\Modbus\;..\SRC\buffer\;..\SRC\hsur\;..\SRC\management\;..\SRC\dhcp\;..\SRC\pppoe\;..\SRC\flash;..\SRC\SNTP;..\SRC\display;..\SRC\key;..\SRC\schedule;..\SRC\program;..\SRC\Scan;..\SRC\bacnet;..\src\bacnet\include;..\src\bacnet\object;..\src\bacnet\handler
  asm include: .;..\SRC\CPU\;..\SRC\SW_DMA\;..\SRC\ETHERNET\;..\SRC\ADAPTER;..\SRC\main
  link misc: NOOVERLAY
  group FreeRTOS
    ../SRC/FreeRTOSSource/: list.c queue.c tasks.c
    ../SRC/FreeRTOSSource/include/: semphr.h task.h
  group FreeRTOS Port
    ../SRC/FreeRTOSSource/portable/Keil/AX11000/: port.c OS_CPU_A.A51 portmacro.h
    ../SRC/FreeRTOSSource/portable/MemMang/: heap_1.c
  group CPU
    ../SRC/CPU/: ax11000.c ax11000_cfg.h interrupt.c interrupt_cfg.h START390.A51
  group DMA
    ../SRC/SW_DMA/: dma_cfg.h busreq.asm dma.c
  group MSTIMER
    ../SRC/MS_TIMER/: mstimer_cfg.h delay.c
    ./MS_TIMER/: mstimer.c
  group UART
    ../SRC/UART/: uart.c
  group main
    ../SRC/main/: main.c
    ./main/: tcpip_task.c
  group Application
    ./application/: httpd.c
    ./ADAPTER/: adapter.c
  group Modbus
    ./Modbus/: serialnew.c
  group I2C
    ./I2C/: i2capi.c clock.c E2prom.c i2c.c
  group PCA
    ./PCA/: pca.c
  group buffer
    ./Buffer/: buffer.c
  group ethernet
    ./ethernet/: mac.c phy.c stoe.c
  group tcpip
    ./tcpip/: uip.c uip_arch.c uip_arp.c tcpip.LIB
  group management
    ./management/: gconfig.c gudpbc.c
  group dhcp
    ./dhcp/: dhcpc.c
  group pppoe
    ./pppoe/: pppoe.c
  group output
    ./Modbus/: Output.c
  group flash
    ./Flash/: flash.c flash_schedule.c
  group sntpc
    ./SNTP/: sntpc.c
  group display
    ./display/: LCD.c Display.c font.c
  group key
    ./key/: key.c
  group input
    ./Modbus/: pic.c Input.c sI2C.c
  group schedule
    ./schedule/: schedule.c
  group CommToTst
    ./scan/: scan.c commsub.c
  group bacnet
    ./bacnet/src/: bacdcode.c bacreal.c bacint.c bacstr.c mstptext.c bacaddr.c bacapp.c bacprop.c bacpropstates.c datalink.c datetime.c dcc.c indtext.c crc.c bacerror.c npdu.c iam.c abort.c reject.c fifo.c apdu.c ptransfer.c bip.c bvlc.c whois.c
    ./bacnet/handler/: h_npdu.c txbuf.c s_iam.c s_upt.c noserv.c
    ./bacnet/: device.c dlmstp.c rs485.c timer.c user_data.c decode.c POINT.C bac_control.c monitor.c h_whois.c
