# Keil uVision project AX11000_0k.uvproj, settings and files
target FREERTOS (MCS-51)
  device: DP80390XP Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2 MOD517AU
  output: ax11000 +hex
  AfterMake: .\BUILD\hex2bin -s 0000 .\BUILD\ax11000.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: KEIL_AX11000
  c include: ..\SRC\FreeRTOSSource\include\;..\SRC\FreeRTOSSource\portable\Keil\AX11000;..\SRC\CPU\;..\SRC\MS_TIMER\;..\SRC\SW_DMA\;..\SRC\UART\;..\SRC\ETHERNET\;..\SRC\APPLICATION\;..\SRC\ETHERNET\;..\SRC\tcpip\;..\SRC\ADAPTER;..\SRC\main;..\SRC\SD_Card\;..\SRC\GSM\;..\SRC\Web\;..\SRC\SPI\;..\SRC\I2C\;..\SRC\PCA\;..\SRC\Modbus\;..\SRC\buffer\;..\SRC\hsur\;..\SRC\management\;..\SRC\dhcp\;..\SRC\pppoe\;..\SRC\MINI_262\;..\SRC\flash;..\SRC\SNTP
  asm include: .;..\SRC\CPU\;..\SRC\SW_DMA\;..\SRC\ETHERNET\;..\SRC\ADAPTER;..\SRC\main
  link misc: NOOVERLAY
  group FreeRTOS
    ../SRC/FreeRTOSSource/: list.c queue.c tasks.c
    ../SRC/FreeRTOSSource/include/: semphr.h task.h
  group FreeRTOS Port
    ../SRC/FreeRTOSSource/portable/Keil/AX11000/: port.c OS_CPU_A.A51 portmacro.h
    ../SRC/FreeRTOSSource/portable/MemMang/: heap_1.c
  group CPU
    ../SRC/CPU/: ax11000.c ax11000_cfg.h interrupt.c interrupt_cfg.h START390.A51
  group DMA
    ../SRC/SW_DMA/: dma_cfg.h busreq.asm dma.c
  group MSTIMER
    ../SRC/MS_TIMER/: mstimer_cfg.h delay.c
    ./MS_TIMER/: mstimer.c
  group UART
    ../SRC/UART/: uart_cfg.h uart.c
    ./hsur/: hsuart.c
  group main
    ../SRC/main/: main.c
    ./main/: tcpip_task.c bacnet_task.c
  group SPI
    ./SPI/: spi.c spiapi.c
  group Application
    ./application/: httpd.c
    ./web/: filesys.c web_fun.c
    ./ADAPTER/: adapter.c
  group Modbus
    ./Modbus/: serialnew.c
  group I2C
    ./I2C/: i2capi.c clock.c E2prom.c i2c.c
  group PCA
    ./PCA/: pca.c
  group buffer
    ./Buffer/: buffer.c
  group ethernet
    ./ethernet/: mac.c phy.c stoe.c
  group tcpip
    ./tcpip/: tcpip.LIB uip.c uip_arch.c uip_arp.c
  group management
    ./management/: gconfig.c gudpbc.c
  group dhcp
    ./dhcp/: dhcpc.c
  group pppoe
    ./pppoe/: pppoe.c
  group Bacnet
    ./MINI_262/: VIRT.C APPLAYER.C CONST.C CONTROL.C DATA.C MONITOR.C MSTP.C NETLAYER.C POINT.C PTP.C SERVER.C int.c bacnetflag.c
  group output
    ./Modbus/: Output.c range.c pic.c
  group commTop
    ./Modbus/: comm.c
  group flash
    ./Flash/: flash.c
  group sntpc
    ./SNTP/: sntpc.c
