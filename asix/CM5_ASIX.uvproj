# Keil uVision project CM5_ASIX.uvproj, settings and files
target FREERTOS (MCS-51)
  device: DP80390XP Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2 MOD517AU
  output: ax11000 +hex
  AfterMake: .\BUILD\hex2bin -s 0000 .\BUILD\ax11000.hex
  AfterMake: .\BUILD\makeruntime.exe .\BUILD\ax11000.bin .\binfile\cm5_asix_revxx.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: KEIL_AX11000
  c include: .\FreeRTOSSource\include;.\FreeRTOSSource\portable\Keil\AX11000;.\CPU\;.\MS_TIMER;.\SW_DMA\;.\UART\;.\ETHERNET\;.\tcpip\;.\ADAPTER;.\SPI\;.\I2C\;.\PCA\;.\Modbus\;.\buffer\;.\hsur\;.\management\;.\dhcp\;.\pppoe\;.\flash;.\SNTP;..\display;..\key;..\scan;.\usb;..\common;.\CM5;.\MINI;.\dyndns;.\http;.\web;..\SD\FATFS\exfuns;..\SD\SDCARD;..\SD\FATFS\src;.\ping;..\bacnet\private;..\bacnet\include;..\bacnet\;..\IO_control;.\dns;.\modbus;.\pic;.\RM;.\output;.\timesync;.\SDCARD;..\SNTP
  asm include: .;.\CPU\;.\SW_DMA\;.\ETHERNET\;.\ADAPTER;.\main
  link misc: NOOVERLAY
  group FreeRTOS
    ./FreeRTOSSource/: list.c queue.c tasks.c
  group FreeRTOS Port
    ./FreeRTOSSource/portable/Keil/AX11000/: OS_CPU_A.A51 port.c
    ./FreeRTOSSource/portable/MemMang/: heap_1.c
  group CPU
    ./CPU/: ax11000.c interrupt.c START390.A51
  group DMA
    ./SW_DMA/: busreq.asm dma.c
  group MSTIMER
    ./MS_TIMER/: mstimer.c delay.c
  group UART
    ./hsur/: hsuart.c
    ./UART/: uart.c
  group SPI
    ./SPI/: spi.c spiapi.c
  group Adapter
    ./ADAPTER/: adapter.c
  group I2C
    ./I2C/: i2capi.c clock.c E2prom.c i2c.c
  group PCA
    ./PCA/: pca.c
  group buffer
    ./Buffer/: buffer.c
  group ethernet
    ./ethernet/: mac.c phy.c stoe.c
  group tcpip
    ./tcpip/: uip_arp.c uip.c uip_arch.c tcpip.LIB
  group management
    ./management/: gconfig.c gudpbc.c
  group pppoe
    ./pppoe/: pppoe.c
  group dhcp
    ./dhcp/: dhcpc.c
  group Bacnet_common
    ../bacnet/: bac_interface.c bip.c
    D:/Work/MinPanel/Code/bacnetlib/SRC/bacnet/: bacnet_asix.LIB
  group bacnet_private
    ../bacnet/private/: alarm.c bac_control.c decode.c MONITOR.C POINT.C ptransfer.c user_data.c
  group flash
    ./Flash/: flash.c
  group display
    ../display/: Display.c ER-TFT024-3_4-Wire_SPI.c font.c LCD.c
  group key
    ../key/: key.c
  group comm_to_sub
    ../scan/: commsub.c scan.c
  group usb
    ./usb/: descriptor_COM.c usb.c ch375usb.c
  group CM5
    ./CM5/: Input.c
  group MINI
    ../common/: comm.c
  group common_app
    ./binfile/: MINI_revison.TXT CM5_revison.TXT
    ./tcpip/: tcpip_task.c
    ../common/: info.c main.c range.c modbus.c pic.c Output.c
    ./modbus/: modbustcp.c
    ./Flash/: flash_user.c
  group dyndns
    ./dyndns/: dyndns.c dyndns_app.c
  group sntp
    ../SNTP/: sntpc.c
  group SD_BIG
    ../SD/FATFS/src/: ff.c diskio.c
    ../SD/FATFS/exfuns/: exfuns.c
    ./SDCARD/: MMC_SD.C
  group io_control
    ../IO_control/: io.c io_control_asix.LIB
  group dns
    ./dns/: dnsc.c
  group RM
    ./RM/: remote_connect.c
  group timesync
    ./timesync/: timesync.c
